# Keil uVision project project.uvproj, settings and files
target RT-Thread STM32 Radio (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,
  c misc: --diag_suppress=870
  c include: .;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\rt-thread\include;.\rt-thread\libcpu\arm\stm32;.\rt-thread\components\finsh;.\rt-thread\components\net\lwip\src;.\rt-thread\components\net\lwip\src\include;.\rt-thread\components\net\lwip\src\arch\include;.\rt-thread\components\net\lwip\src\include\ipv4;.\rt-thread\components\dfs;.\rt-thread\components\dfs\include;.\rt-thread\components\dfs\filesystems\efsl\src\include;.\rt-thread\components\dfs\filesystems\efsl\src\base\include;.\rt-thread\components\dfs\filesystems\efsl\src\fs\vfat\include;.\rt-thread\components\rtgui\include;.\rt-thread\components\rtgui\common\libz
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Startup
    ./: rtconfig.h board.h stm32f10x_conf.h application.c board.c startup.c stm32f10x_it.c usart.c sdcard.c rtc.c fsmc_sram.c http.c lcd.c mp3.c wav.c netbuffer.c key.c info.c device_info.c player_ui.c player_bg.c play_list.c remote.c picture.c station_list.c touch.c radio_list_update.c calibration.c dm9000a.c setup.c ili_lcd_general.c utils.c drawpad.c JSON_parser.c douban_radio.c douban_channel.c system_stm32f10x.c pcm1770.c iis.c cxf_cmd.c
    ./apps/: ftpd.c ping.c agent.c
  group Kernel
    ./rt-thread/src/: clock.c idle.c ipc.c mempool.c mem.c object.c scheduler.c thread.c timer.c irq.c kservice.c device.c slab.c
  group STM32
    ./rt-thread/libcpu/arm/stm32/: stack.c interrupt.c cpu.c serial.c context_rvds.S start_rvds.s fault.c fault_rvds.S
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-FS-Device_Driver
    ./Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group finsh
    ./rt-thread/components/finsh/: finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c cmd.c
  group Filesystem
    ./rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ./rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group LwIP
    ./rt-thread/components/net/lwip/src/core/: dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ./rt-thread/components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./rt-thread/components/net/lwip/src/core/snmp/: msg_in.c msg_out.c
    ./rt-thread/components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c sockets.c
    ./rt-thread/components/net/lwip/src/netif/: etharp.c ethernetif.c loopif.c
    ./rt-thread/components/net/lwip/src/arch/: sys_arch_init.c sys_arch.c
  group mp3
    ./mp3/: mp3dec.c mp3tabs.c
    ./mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ./mp3/real/arm/: asmpoly_thumb2.s asmmisc.s
  group RTGUI
    ./rt-thread/components/rtgui/common/: rtgui_object.c rtgui_system.c rtgui_theme.c asc12font.c asc16font.c color.c dc.c dc_buffer.c dc_hw.c filerw.c font.c image.c image_xpm.c image_hdc.c region.c font_hz_file.c hz16font.c hz12font.c dc_client.c font_bmp.c blit.c
    ./rt-thread/components/rtgui/server/: server.c driver.c panel.c mouse.c topwin.c
    ./rt-thread/components/rtgui/widgets/: widget.c window.c workbench.c view.c box.c button.c container.c iconbox.c label.c textbox.c title.c toplevel.c scrollbar.c list_view.c filelist_view.c listbox.c slider.c
  group Mass_Storage
    ./Libraries/Mass_Storage/src/: hw_config.c mass_mal.c memory.c usb_bot.c scsi_data.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c usb_main.c
